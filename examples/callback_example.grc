<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>callback_example</value></param>
<param><key>author</key><value>DZ Labs, LLC</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>XML Callback Example</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>bitstream</value></param>
<param><key>value</key><value>"01010101"</value></param>
<param><key>label</key><value>Bit Stream</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>2000</value></param>
</block>
<block>
<key>callback_xml_demod</key>
<param><key>id</key><value>callback_xml_demod_0</value></param>
<param><key>bitstream</key><value>bitstream</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>callback_xml_demod_0</sink_block_id><source_key>strobe</source_key><sink_key>in</sink_key></connection>
</flow_graph>
